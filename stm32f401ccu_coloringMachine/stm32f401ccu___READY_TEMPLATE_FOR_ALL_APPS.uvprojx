# Keil uVision project stm32f401ccu___READY_TEMPLATE_FOR_ALL_APPS.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f401ccu___READY_TEMPLATE_FOR_ALL_APPS +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: main.c app.c stepper.c adc.c alarm.c dh11.c ticker.c dye_modes.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0, CMSIS:RTOS2:Keil RTX5 5.5.4, CMSIS Driver:SPI 2.18, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:SPI 1.8.1, Device:Startup 2.6.3, Graphics:CORE 6.32.3, Graphics:Display:Interface Template 6.32.3
